# Repository nikitalita/I2S-Hat

## KiCad design I2SHat/I2SHat.kicad_pcb

Parts:
A1: Arduino_Nano_v3.x; Arduino_Nano
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C14, C18, C20, C22, C24: 100n; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C12, C13, C17: 1u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C15, C16: 22p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C19, C21, C23, C25: 47u; C_Elec_6.3x5.8; Mouser Part Number 667-EEH-ZA1E470P
D1: SS1P3L-M3/84A; SS1P3L-M3&slash_84A
FB1, FB2, FB3, FB4: Ferrite_Bead_Small; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
H1, H2: MountingHole; MountingHole_2.7mm_M2.5_Pad
J1: TORX142L; Mouser Part Number 638-PLR135T9
J2: TOTX142L; Mouser Part Number 638-PLR135T9
J3: TX_RCA; CUI_RCJ-04X
J4: Raspberry_Pi_2_3; PinHeader_2x20_P2.54mm_Vertical
J5: RX_RCA; CUI_RCJ-04X
L1, L2, L3: 47uH; L_Taiyo-Yuden_NR-24xx_HandSoldering; Mouser Part Number 963-CB2518T470K
Q1, Q2, Q3, Q4, Q5: BSS138; SOT-23-3; MPN BSS138-7-F; Digi-Key_PN BSS138-FDICT-ND
R1, R2, R3, R5, R10, R21, R22, R23, R26, R27: 33; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4, R6, R9, R11, R13, R14, R15, R16, R17, R18, R19, R20, R24, R25, R28, R29, R31: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R7: 210; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R8: 110; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R12: 75; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R30: 100K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R32, R33: 110; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: GW12RCP; SW_NKK_G1xJP
TP2: TestPoint; TestPoint_Pad_D1.5mm
TP4, TP5, TP6, TP7: TestPoint; TestPoint_NoSilk_D2.50mm_Drill1.0mm
TP8: TestPoint; TestPoint_Pad_1.0x1.0mm
U1, U3, U4: 74LVC1G125DBV; SOT-753; MPN NC7SZ125M5X; Digi-Key_PN NC7SZ125M5XCT-ND
U2: NC7SZ157P6X; SOT-363_SC-70-6
U5: 74LVC1GU04DBV; SOT-753
U6: 74LV1T04DBV; SOT-753
U8: SN74LV1T34DBV; SOT-753
U9, U10, U11: LD1117S33; SOT-223-3_TabPin2; MPN LD1117S33CTR; Digi-Key_PN 497-1241-1-ND
Y1: ABMM-12.000MHZ; Crystal_SMD_7050-4Pin_7.0x5.0mm

Connections:
+3.3VA: C13.1, C14.1, C25.1, U11.2 (VO); also elsewhere on the board
+3.3VP: C21.1, L1.1, L2.2, L3.1, Q1.1, Q3.1, Q5.1, R13.1, R18.1, R28.1, U9.2 (VO)
+3V3: C11.2, C12.2, C23.1, FB1.2, FB2.2, FB3.2, FB4.2, Q2.1, Q4.1, R4.1, R16.1, R24.1, R30.1, R31.1, U10.2 (VO); also elsewhere on the board
+5V: C19.1, C20.1, C22.1, C24.1, D1.2, J4.2 (5V), J4.4 (5V), U9.3 (VI), U10.3 (VI), U11.3 (VI)
+5VL: A1.27 (+5V), C18.1, D1.1, R14.1, R15.1, R19.1, R25.1, R29.1, U8.5 (VCC)
/3V31: J4.1 (3V3)
/3V32: J4.17 (3V3)
/BCLK: J4.12 (GPIO18/PWM0), R23.2
/DIN_WM: J4.40 (GPIO21/SCLK1), R26.2
/DOUT_WM: J4.38 (GPIO20/MOSI1), R27.1
/GPIO0: J4.27 (ID_SD/GPIO0)
/GPIO1: J4.28 (ID_SC/GPIO1)
/GPIO2: J4.3 (SDA/GPIO2)
/GPIO3: J4.5 (SCL/GPIO3)
/GPIO4: J4.7 (GCLK0/GPIO4)
/GPIO5: J4.29 (GCLK1/GPIO5)
/GPIO6: J4.31 (GCLK2/GPIO6)
/GPIO7: J4.26 (~CE1/GPIO7)
/GPIO8: J4.24 (~CE0/GPIO8)
/GPIO9: J4.21 (MISO0/GPIO9)
/GPIO10: J4.19 (MOSI0/GPIO10)
/GPIO11: J4.23 (SCLK0/GPIO11)
/GPIO12: J4.32 (PWM0/GPIO12)
/GPIO13: J4.33 (PWM1/GPIO13)
/GPIO14: J4.8 (GPIO14/TXD)
/GPIO15: J4.10 (GPIO15/RXD)
/GPIO16: J4.36 (GPIO16)
/GPIO17: J4.11 (GPIO17), Q5.2, R28.2
/GPIO22: J4.15 (GPIO22), Q1.2, R13.2
/GPIO23: J4.16 (GPIO23)
/GPIO24: J4.18 (GPIO24)
/GPIO25: J4.22 (GPIO25)
/GPIO26: J4.37 (GPIO26)
/GPIO27: J4.13 (GPIO27), Q3.2, R18.2
/LRCLK: J4.35 (GPIO19/MISO1), R22.2, R33.2
/RST: C17.2, R30.2; also elsewhere on the board
/RX: R2.2; also elsewhere on the board
/SCL: A1.24 (A5), Q4.3, R25.2
/SDA: A1.23 (A4), Q2.3, R15.2
/TX: R3.2, R7.2; also elsewhere on the board
GNDREF: A1.4 (GND), A1.29 (GND), C1.2, C2.2, C3.2, C4.2, C5.2, C8.2, C9.2, C10.2, C11.1, C12.1, C13.2, C14.2, C15.2, C16.1, C17.1, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, J1.2 (GND), J2.1 (GND), J3.2 (Ext), J4.6 (GND), J4.9 (GND), J4.14 (GND), J4.20 (GND), J4.25 (GND), J4.30 (GND), J4.34 (GND), J4.39 (GND), J5.2 (Ext), R6.1, R8.2, R11.2, R12.2, R17.1, R20.1, U1.1 (~OE), U1.3 (GND), U2.2 (GND), U3.1 (~OE), U3.3 (GND), U4.1 (~OE), U4.3 (GND), U5.3 (GND), U6.3 (GND), U8.3 (GND), U9.1 (GND), U10.1 (GND), U11.1 (GND), Y1.2, Y1.4; also elsewhere on the board
unnamed: A1.8 (D5), Q1.3, R14.2
unnamed: A1.9 (D6), Q3.3, R19.2
unnamed: A1.10 (D7), Q5.3, R29.2
unnamed: A1.11 (D8), R32.1
unnamed: C1.1, FB2.1, U2.5 (VCC)
unnamed: C2.1, FB3.1, U3.5 (VCC)
unnamed: C3.1, FB1.1, U1.5 (VCC)
unnamed: C4.1, J1.3 (VCC), L1.2
unnamed: C5.1, J2.2 (VCC), L2.1
unnamed: C6.1, R7.1, R8.1
unnamed: C6.2, J3.1 (In)
unnamed: C7.1, R9.1, U5.2
unnamed: C7.2, J5.1 (In), R12.1
unnamed: C8.1, C9.1, L3.2, U5.5 (VCC), U6.5 (VCC)
unnamed: C10.1, FB4.1, U4.5 (VCC)
unnamed 77: C15.1, Y1.1; also elsewhere on the board
unnamed 78: C16.2, Y1.3; also elsewhere on the board
unnamed: J1.1 (VOUT), U1.2 (A)
unnamed: J2.3 (Input), U3.4 (Y)
unnamed 81: Q2.2, R16.2; also elsewhere on the board
unnamed 82: Q4.2, R24.2; also elsewhere on the board
unnamed: R1.1, U2.3 (I0)
unnamed: R1.2, U1.4 (Y)
unnamed: R2.1, U2.4 (Z)
unnamed: R3.1, U3.2 (A)
unnamed: R4.2, SW1.4 (A)
unnamed: R5.1, U2.1 (I1)
unnamed: R5.2, U4.4 (Y)
unnamed: R6.2, SW1.6 (C)
unnamed: R10.1, U4.2 (A)
unnamed: R10.2, U6.4
unnamed: R9.2, R11.1, U5.4, U6.2
unnamed 94: R17.2; also elsewhere on the board
unnamed 95: R20.2; also elsewhere on the board
unnamed 96: R21.1; also elsewhere on the board
unnamed: R21.2, TP2.1
unnamed 98: R22.1; also elsewhere on the board
unnamed 99: R23.1; also elsewhere on the board
unnamed 100: R26.1; also elsewhere on the board
unnamed 101: R27.2; also elsewhere on the board
unnamed 102: R31.2; also elsewhere on the board
unnamed: R32.2, U8.4 (Y)
unnamed: R33.1, U8.2 (A)
unnamed: SW1.5 (B), U2.6 (S)
unnamed 113: TP8.1; also elsewhere on the board

Board: 4 copper layers, 65.0 x 56.0 mm, 98 parts (41 on the bottom side), 63 nets.

Other parts of the board:
U7: WM8804; SSOP-20_5.3x7.2mm_P0.65mm

Their connections:
+3.3VA: U7.7; also elsewhere on the board
+3V3: U7.19; also elsewhere on the board
/RST: U7.6; also elsewhere on the board
/RX: U7.20; also elsewhere on the board
/TX: U7.17; also elsewhere on the board
GNDREF: U7.8, U7.18; also elsewhere on the board
unnamed 77: U7.10; also elsewhere on the board
unnamed 78: U7.11; also elsewhere on the board
unnamed 81: U7.3; also elsewhere on the board
unnamed 82: U7.1; also elsewhere on the board
unnamed 94: U7.2; also elsewhere on the board
unnamed 95: U7.5; also elsewhere on the board
unnamed 96: U7.16; also elsewhere on the board
unnamed 98: U7.15; also elsewhere on the board
unnamed 99: U7.14; also elsewhere on the board
unnamed 100: U7.13; also elsewhere on the board
unnamed 101: U7.12; also elsewhere on the board
unnamed 102: U7.4; also elsewhere on the board
unnamed 113: U7.9; also elsewhere on the board

## Commit log

2023-02-08 WIP changes

Notices in the files:
parts and their libraries:
Copyright 2021 Accelerated Designs. All rights reserved.
